## Kconfig
```kconfig
config RTL8821AU
	tristate "Realtek 8821A USB WiFi"
	depends on USB
	select WIRELESS_EXT
	help
	  Help message of RTL8821AU
```
